v {xschem version=3.4.3 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
B 10 193 -446 217 -420 {fill=true}
B 10 293 -446 317 -420 {fill=true}
B 10 403 -446 427 -420 {fill=true}
B 10 513 -446 537 -420 {fill=true}
B 10 613 -446 637 -420 {fill=true}
B 10 1263 -446 1287 -420 {fill=true}
B 10 1163 -446 1187 -420 {fill=true}
B 10 1053 -446 1077 -420 {fill=true}
B 10 943 -446 967 -420 {fill=true}
B 10 843 -446 867 -420 {fill=true}
P 4 5 2250 -1620 2250 -60 2880 -60 2880 -1620 2250 -1620 {dash=3}
P 4 5 1770 -1620 80 -1620 80 -60 1770 -60 1770 -1620 {dash=3}
P 4 5 0 0 0 -1660 4630 -1660 4630 0 0 0 {}
P 4 5 4630 -80 4630 -1660 4910 -1660 4910 -80 4630 -80 {}
P 4 5 400 -1490 400 -1450 390 -1460 410 -1460 400 -1450 {}
P 4 5 1080 -1490 1080 -1450 1070 -1460 1090 -1460 1080 -1450 {}
P 4 5 4630 -80 4630 -310 4910 -310 4910 -80 4630 -80 {}
P 4 4 575 -360 575 -335 255 -335 255 -360 {}
P 4 3 180 -420 170 -360 160 -360 {}
P 4 4 905 -360 905 -335 1225 -335 1225 -360 {}
P 4 3 1300 -420 1310 -360 1320 -360 {}
P 4 5 2350 -120 2350 -80 2340 -90 2360 -90 2350 -80 {}
P 4 5 1600 -1490 1600 -1450 1590 -1460 1610 -1460 1600 -1450 {}
P 4 5 4630 -1010 4630 -1660 4910 -1660 4910 -1010 4630 -1010 {}
P 4 5 1010 -740 1010 -680 1020 -690 1000 -690 1010 -680 {}
P 4 5 800 -740 800 -680 810 -690 790 -690 800 -680 {}
P 4 5 670 -740 670 -680 660 -690 680 -690 670 -680 {}
P 4 5 380 -740 380 -680 390 -690 370 -690 380 -680 {}
P 4 5 450 -1200 450 -1140 440 -1150 460 -1150 450 -1140 {}
P 4 5 1030 -1210 1030 -1150 1040 -1160 1020 -1160 1030 -1150 {}
P 4 5 3130 -1490 3130 -1450 3120 -1460 3140 -1460 3130 -1450 {}
P 4 5 2110 -1490 2110 -1450 2100 -1460 2120 -1460 2110 -1450 {}
P 4 5 1810 -1620 1810 -60 2210 -60 2210 -1620 1810 -1620 {dash=3}
P 4 5 1910 -120 1910 -80 1900 -90 1920 -90 1910 -80 {}
P 4 5 2110 -120 2110 -80 2100 -90 2120 -90 2110 -80 {}
P 4 5 2920 -1620 2920 -60 3580 -60 3580 -1620 2920 -1620 {dash=3}
P 4 5 3400 -1490 3400 -1450 3390 -1460 3410 -1460 3400 -1450 {}
P 4 5 3730 -1620 3730 -60 4390 -60 4390 -1620 3730 -1620 {dash=3}
P 4 5 4050 -1480 4050 -1440 4040 -1450 4060 -1450 4050 -1440 {}
P 4 5 4060 -120 4060 -80 4050 -90 4070 -90 4060 -80 {}
P 4 5 4240 -1480 4240 -1440 4230 -1450 4250 -1450 4240 -1440 {}
P 4 5 4240 -120 4240 -80 4230 -90 4250 -90 4240 -80 {}
P 4 2 4630 -1010 4910 -1010 {dash=3}
P 4 2 4630 -830 4910 -830 {dash=3}
P 4 5 2590 -120 2590 -80 2580 -90 2600 -90 2590 -80 {}
P 4 5 3850 -120 3850 -80 3840 -90 3860 -90 3850 -80 {}
P 4 5 3850 -1480 3850 -1440 3840 -1450 3860 -1450 3850 -1440 {}
P 6 5 500 -420 550 -420 554 -395 496 -395 500 -420 {fill=false}
P 6 5 1200 -420 1150 -420 1146 -395 1204 -395 1200 -420 {fill=false}
P 6 5 980 -420 930 -420 926 -395 984 -395 980 -420 {fill=false}
P 6 17 255 -360 270 -360 276 -395 334 -395 340 -360 370 -360 376 -395 454 -395 460 -360 490 -360 496 -395 554 -395 560 -360 575 -360 575 -335 255 -335 255 -360 {fill=true}
P 6 5 280 -420 330 -420 334 -395 276 -395 280 -420 {fill=false}
P 6 17 1225 -360 1210 -360 1204 -395 1146 -395 1140 -360 1110 -360 1104 -395 1026 -395 1020 -360 990 -360 984 -395 926 -395 920 -360 905 -360 905 -335 1225 -335 1225 -360 {fill=true}
P 12 5 230 -420 280 -420 270 -360 240 -360 230 -420 {fill=true}
P 12 5 330 -420 380 -420 370 -360 340 -360 330 -420 {fill=true}
P 12 5 450 -420 500 -420 490 -360 460 -360 450 -420 {fill=true}
P 12 5 550 -420 600 -420 590 -360 560 -360 550 -420 {fill=true}
P 12 5 160 -360 160 -420 180 -420 170 -360 160 -360 {fill=true}
P 12 5 670 -360 670 -420 650 -420 660 -360 670 -360 {fill=true}
P 12 5 1250 -420 1200 -420 1210 -360 1240 -360 1250 -420 {fill=true}
P 12 5 1150 -420 1100 -420 1110 -360 1140 -360 1150 -420 {fill=true}
P 12 5 1030 -420 980 -420 990 -360 1020 -360 1030 -420 {fill=true}
P 12 5 930 -420 880 -420 890 -360 920 -360 930 -420 {fill=true}
P 12 5 1320 -360 1320 -420 1300 -420 1310 -360 1320 -360 {fill=true}
P 12 5 810 -360 810 -420 830 -420 820 -360 810 -360 {fill=true}
P 13 5 180 -420 230 -420 234 -395 176 -395 180 -420 {fill=true}
P 13 5 380 -420 450 -420 454 -395 376 -395 380 -420 {fill=true}
P 13 5 600 -420 650 -420 654 -395 596 -395 600 -420 {fill=true}
P 13 5 1300 -420 1250 -420 1246 -395 1304 -395 1300 -420 {fill=true}
P 13 5 1100 -420 1030 -420 1026 -395 1104 -395 1100 -420 {fill=true}
P 13 5 880 -420 830 -420 826 -395 884 -395 880 -420 {fill=true}
P 15 18 160 -270 160 -360 170 -360 176 -395 233 -395 234 -395 240 -360 255 -360 255 -335 575 -335 575 -360 590 -360 596 -395 654 -395 660 -360 670 -360 670 -270 160 -270 {fill=true}
P 15 18 1320 -270 1320 -360 1310 -360 1304 -395 1247 -395 1246 -395 1240 -360 1225 -360 1225 -335 905 -335 905 -360 890 -360 884 -395 826 -395 820 -360 810 -360 810 -270 1320 -270 {fill=true}
T {Startup} 2270 -1610 0 0 0.4 0.4 {}
T {Bandgap Reference} 100 -1610 0 0 0.4 0.4 {}
T {1.5x
} 388 -1525 0 0 0.4 0.4 {}
T {1x} 1068 -1525 0 0 0.4 0.4 {}
T {P-Substrate} 630 -290 0 1 0.2 0.2 {}
T {N-well} 550 -360 0 1 0.2 0.2 {}
T {P+} 423 -414 0 1 0.2 0.2 {}
T {N+} 533 -414 0 1 0.2 0.2 {}
T {P+} 633 -414 0 1 0.2 0.2 {}
T {P+} 213 -414 0 1 0.2 0.2 {}
T {N+} 313 -414 0 1 0.2 0.2 {}
T {B} 528 -441 0 1 0.2 0.2 {}
T {B} 308 -441 0 1 0.2 0.2 {}
T {E} 418 -441 0 1 0.2 0.2 {}
T {C} 629 -440 0 1 0.2 0.2 {}
T {C} 208 -441 0 1 0.2 0.2 {}
T {P-Substrate} 850 -290 0 0 0.2 0.2 {}
T {N-well} 930 -360 0 0 0.2 0.2 {}
T {P+} 1057 -414 0 0 0.2 0.2 {}
T {N+} 947 -414 0 0 0.2 0.2 {}
T {P+} 847 -414 0 0 0.2 0.2 {}
T {P+} 1267 -414 0 0 0.2 0.2 {}
T {N+} 1167 -414 0 0 0.2 0.2 {}
T {B} 952 -441 0 0 0.2 0.2 {}
T {B} 1172 -441 0 0 0.2 0.2 {}
T {E} 1062 -441 0 0 0.2 0.2 {}
T {C} 851 -440 0 0 0.2 0.2 {}
T {C} 1272 -441 0 0 0.2 0.2 {}
T {0x} 2338 -155 0 0 0.4 0.4 {}
T {1x} 3118 -1525 0 0 0.4 0.4 {}
T {0.5x} 2098 -1525 0 0 0.4 0.4 {}
T {Self-Bias} 1830 -1610 0 0 0.4 0.4 {}
T {0.25x
} 1898 -155 0 0 0.4 0.4 {}
T {0.5x
} 2098 -155 0 0 0.4 0.4 {}
T {Output} 2940 -1610 0 0 0.4 0.4 {}
T {2x
} 1585 -1525 0 0 0.4 0.4 {}
T {1x
} 3388 -1525 0 0 0.4 0.4 {}
T {Enable/Disable} 3750 -1600 0 0 0.4 0.4 {}
T {0x} 4038 -1515 0 0 0.4 0.4 {}
T {0x} 4048 -155 0 0 0.4 0.4 {}
T {0x} 4228 -1515 0 0 0.4 0.4 {}
T {0x} 4228 -155 0 0 0.4 0.4 {}
T {Dummies} 4730 -930 0 0 0.4 0.4 {}
T {0x} 2578 -155 0 0 0.4 0.4 {}
T {0x} 3838 -155 0 0 0.4 0.4 {}
T {0x} 3838 -1515 0 0 0.4 0.4 {}
N 1080 -1420 1600 -1420 {lab=vdd}
N 2750 -1420 4450 -1420 {lab=vdd}
N 750 -1300 1040 -1300 {lab=gate}
N 2750 -180 4440 -180 {lab=vss}
N 400 -1420 1080 -1420 {lab=vdd}
N 2110 -180 2350 -180 {lab=vss}
N 2470 -1420 2750 -1420 {lab=vdd}
N 2110 -1420 2470 -1420 {lab=vdd}
N 1080 -900 1080 -740 {
lab=vy}
N 1080 -1420 1080 -1330 {
lab=vdd}
N 400 -1420 400 -1330 {
lab=vdd}
N 400 -300 610 -300 {
lab=vss}
N 440 -350 510 -350 {
lab=vss}
N 610 -480 610 -300 {
lab=vss}
N 610 -480 740 -480 {
lab=vss}
N 510 -480 510 -350 {
lab=vss}
N 510 -480 610 -480 {
lab=vss}
N 740 -480 870 -480 {
lab=vss}
N 740 -480 740 -180 {
lab=vss}
N 740 -180 1910 -180 {
lab=vss}
N 870 -300 1080 -300 {
lab=vss}
N 970 -350 1040 -350 {
lab=vss}
N 870 -480 870 -300 {
lab=vss}
N 970 -480 970 -350 {
lab=vss}
N 870 -480 970 -480 {
lab=vss}
N 1600 -1420 2110 -1420 {lab=vdd}
N 440 -1300 750 -1300 {lab=gate}
N 400 -500 400 -380 {
lab=#net1}
N 1080 -500 1080 -380 {
lab=vbe2}
N 1080 -680 1080 -560 {
lab=#net2}
N 400 -840 400 -560 {
lab=vx}
N 1080 -900 1530 -900 {
lab=vy}
N 400 -840 1530 -840 {
lab=vx}
N 1080 -940 1080 -900 {
lab=vy}
N 400 -940 400 -840 {
lab=vx}
N 1600 -940 1600 -910 {
lab=#net3}
N 1600 -1420 1600 -1000 {
lab=vdd}
N 1080 -1150 1080 -1100 {
lab=vy}
N 400 -1140 400 -1100 {
lab=vx}
N 4760 -1540 4820 -1540 {
lab=tio[7:6]}
N 1580 -820 1580 -760 {
lab=bias}
N 400 -1000 400 -940 {
lab=vx}
N 1080 -1000 1080 -940 {
lab=vy}
N 870 -760 870 -740 {
lab=vy}
N 870 -890 870 -760 {
lab=vy}
N 3130 -1420 3130 -1330 {
lab=vdd}
N 3130 -1270 3130 -670 {
lab=vbg}
N 3130 -790 3610 -790 {
lab=vbg}
N 610 -840 610 -740 {
lab=vx}
N 870 -900 1080 -900 {
lab=vy}
N 870 -900 870 -890 {
lab=vy}
N 400 -1270 400 -1210 {
lab=#net4}
N 400 -1210 400 -1200 {
lab=#net4}
N 1080 -1270 1080 -1210 {
lab=#net5}
N 870 -680 870 -560 {
lab=#net6}
N 870 -500 870 -480 {
lab=vss}
N 610 -680 610 -560 {
lab=#net7}
N 610 -500 610 -480 {
lab=vss}
N 2110 -1270 2110 -700 {
lab=vb1}
N 2110 -700 2110 -630 {
lab=vb1}
N 2010 -600 2070 -600 {
lab=vb1}
N 2010 -700 2010 -600 {
lab=vb1}
N 2010 -700 2110 -700 {
lab=vb1}
N 1970 -1300 2070 -1300 {
lab=gate}
N 1970 -1300 1970 -870 {
lab=gate}
N 1910 -570 1910 -270 {
lab=vss}
N 2110 -570 2110 -270 {
lab=vss}
N 1910 -270 1910 -180 {
lab=vss}
N 2110 -270 2110 -180 {
lab=vss}
N 1950 -600 2010 -600 {
lab=vb1}
N 1910 -180 2110 -180 {lab=vss}
N 1910 -700 1910 -630 {
lab=bias}
N 2110 -1360 2110 -1330 {
lab=vdd}
N 2110 -1420 2110 -1370 {
lab=vdd}
N 2110 -1370 2110 -1360 {
lab=vdd}
N 1910 -180 2110 -180 {
lab=vss}
N 1580 -760 1580 -700 {
lab=bias}
N 400 -1040 400 -1000 {
lab=vx}
N 1080 -1040 1080 -1000 {
lab=vy}
N 3130 -610 3130 -490 {
lab=#net8}
N 3130 -370 3130 -180 {
lab=vss}
N 3400 -1420 3400 -1330 {
lab=vdd}
N 3400 -1270 3400 -1170 {
lab=iout}
N 3400 -1170 3610 -1170 {
lab=iout}
N 4050 -1420 4050 -1200 {
lab=vdd}
N 4240 -840 4240 -760 {
lab=enb}
N 4280 -870 4330 -870 {
lab=en}
N 4330 -870 4330 -730 {
lab=en}
N 4280 -730 4330 -730 {
lab=en}
N 4330 -800 4450 -800 {
lab=en}
N 4240 -1420 4240 -900 {
lab=vdd}
N 4240 -700 4240 -180 {
lab=vss}
N 4050 -480 4050 -180 {
lab=vss}
N 2350 -620 2350 -180 {
lab=vss}
N 1970 -870 2270 -870 {
lab=gate}
N 2270 -870 2330 -870 {
lab=gate}
N 2350 -740 2350 -680 {
lab=vss}
N 2350 -680 2350 -620 {
lab=vss}
N 2340 -870 2350 -870 {
lab=gate}
N 2330 -870 2340 -870 {
lab=gate}
N 2750 -670 2750 -180 {
lab=vss}
N 2750 -770 2750 -730 {
lab=vs1}
N 3850 -1420 3850 -1200 {
lab=vdd}
N 2590 -180 2750 -180 {
lab=vss}
N 2350 -180 2590 -180 {
lab=vss}
N 2550 -770 2590 -770 {
lab=vs3}
N 2390 -770 2490 -770 {
lab=vs2}
N 2590 -770 2590 -630 {
lab=vs3}
N 2590 -770 2630 -770 {
lab=vs3}
N 2690 -770 2750 -770 {
lab=vs1}
N 2590 -570 2590 -180 {
lab=vss}
N 3850 -480 3850 -180 {
lab=vss}
N 400 -320 400 -300 {
lab=vss}
N 1080 -1100 1080 -1040 {
lab=vy}
N 400 -1100 400 -1040 {
lab=vx}
N 1080 -320 1080 -300 {
lab=vss}
N 1580 -700 1910 -700 {
lab=bias}
N 1650 -870 1700 -870 {
lab=eao}
N 1910 -870 1970 -870 {
lab=gate}
N 1820 -870 1850 -870 {
lab=gate}
N 1700 -870 1760 -870 {
lab=eao}
N 3170 -430 3610 -430 {
lab=trim[7:0]}
N 2350 -870 2350 -800 {
lab=gate}
N 4770 -780 4800 -780 {
lab=vdd}
N 4800 -780 4800 -720 {
lab=vdd}
N 4770 -720 4800 -720 {
lab=vdd}
N 4730 -720 4770 -720 {
lab=vdd}
N 4730 -750 4730 -720 {
lab=vdd}
N 4730 -780 4730 -750 {
lab=vdd}
N 4730 -780 4770 -780 {
lab=vdd}
N 4770 -750 4800 -750 {
lab=vdd}
N 4730 -670 4730 -640 {
lab=vss}
N 4730 -670 4770 -670 {
lab=vss}
N 4770 -670 4770 -610 {
lab=vss}
N 4730 -610 4770 -610 {
lab=vss}
N 4730 -640 4730 -610 {
lab=vss}
N 4770 -560 4800 -560 {
lab=vss}
N 4800 -560 4800 -500 {
lab=vss}
N 4770 -500 4800 -500 {
lab=vss}
N 4730 -500 4770 -500 {
lab=vss}
N 4730 -530 4730 -500 {
lab=vss}
N 4730 -560 4730 -530 {
lab=vss}
N 4730 -560 4770 -560 {
lab=vss}
N 4770 -530 4800 -530 {
lab=vss}
N 4730 -450 4770 -450 {
lab=vdd}
N 4730 -450 4730 -420 {
lab=vdd}
N 4730 -420 4750 -420 {
lab=vdd}
N 4730 -420 4750 -420 {
lab=vdd}
N 4730 -420 4730 -390 {
lab=vdd}
N 4730 -390 4770 -390 {
lab=vdd}
C {devices/lab_wire.sym} 1600 -830 3 0 {name=l3 sig_type=std_logic lab=vss
}
C {devices/iopin.sym} 4450 -1420 0 0 {name=p1 lab=vdd
}
C {devices/iopin.sym} 4440 -180 0 0 {name=p2 lab=vss
}
C {devices/opin.sym} 3610 -790 0 0 {name=p3 lab=vbg}
C {devices/lab_wire.sym} 720 -1300 0 0 {name=l1 sig_type=std_logic lab=gate}
C {devices/lab_wire.sym} 1080 -1300 0 1 {name=l7 sig_type=std_logic lab=vdd
}
C {devices/lab_wire.sym} 400 -1300 0 0 {name=l8 sig_type=std_logic lab=vdd
}
C {sch/bandgap_cm/bg_amplifier/bg_amplifier.sym} 1680 -870 0 0 {name=xamp
schematic=sch/bandgap_cm/bg_amplifier/bg_amplifier.sch
}
C {devices/lab_wire.sym} 2350 -770 0 0 {name=l11 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 1080 -500 1 1 {name=l20 sig_type=std_logic lab=vbe2
}
C {devices/ngspice_probe.sym} 1530 -900 0 1 {name=r4}
C {devices/ngspice_probe.sym} 1530 -840 0 1 {name=r5}
C {devices/ngspice_probe.sym} 3150 -790 0 0 {name=r6}
C {devices/ngspice_probe.sym} 720 -1300 0 0 {name=r7}
C {devices/ngspice_probe.sym} 400 -840 0 0 {name=r8}
C {devices/ngspice_probe.sym} 400 -560 0 0 {name=r9}
C {devices/ngspice_probe.sym} 1080 -560 0 0 {name=r10}
C {devices/titleblock.sym} 4630 0 0 0 {name=l21 author="Christoph Weiser" license="Apache-2.0" year="2026" }
C {devices/ngspice_get_expr.sym} 420 -1450 0 0 {name=r13 node="i=[to_eng [expr \{ [ ngspice::get_node id_xbg_xm1 ]\} ] ]"
descr=""
}
C {devices/ngspice_get_expr.sym} 1100 -1450 0 0 {name=r14 node="i=[to_eng [expr \{ [ ngspice::get_node id_xbg_xm2 ]\} ] ]"
descr=""
}
C {devices/notes.sym} 4720 -150 0 0 {name=h25
descr=bla
tclcommand="execute 0 sh -c \\"$\{editor\} [file dirname [xschem get schname]]/doc/notes.md\\""
}
C {devices/lab_wire.sym} 740 -480 0 1 {name=l24 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 1580 -820 3 0 {name=l29 sig_type=std_logic lab=bias
}
C {devices/ngspice_get_expr.sym} 2370 -80 0 0 {name=r27 node="i=[to_eng [expr \{ [ ngspice::get_node id_xbg_xms1 ]\} ] ]"
descr=""
}
C {devices/vsource.sym} 400 -530 0 1 {name=vmbjt1 
value=0
lvs_ignore=short
}
C {devices/ngspice_get_expr.sym} 400 -560 0 1 {name=r33 node="i=[to_eng [expr \{ [ ngspice::get_node i(ie_xq1) ]\} ] ]"
descr=""

}
C {devices/vsource.sym} 1080 -530 0 1 {name=vmbjt2 
value=0
lvs_ignore=short
}
C {devices/ngspice_get_expr.sym} 1080 -560 0 1 {name=r30 node="i=[to_eng [expr \{ [ ngspice::get_node i(ie_xq2) ]\} ] ]"
descr=""

}
C {devices/vsource.sym} 1600 -970 0 1 {name=vmamp 
value=0
lvs_ignore=short
}
C {devices/ngspice_get_expr.sym} 1620 -1450 0 0 {name=r31 node="i=[to_eng [expr \{ [ ngspice::get_node i(i_amp) ]\} ] ]"
descr=""

}
C {devices/ngspice_get_expr.sym} 1090 -1270 2 1 {name=r34 node="vsat=[to_eng [expr \{ [ ngspice::get_node vsat_xbg_xm2 ]\} ] ]"
descr=""
}
C {devices/ngspice_get_expr.sym} 410 -1270 2 1 {name=r36 node="vsat=[to_eng [expr \{ [ ngspice::get_node vsat_xbg_xm1 ]\} ] ]"
descr=""
}
C {devices/iopin.sym} 4750 -1600 0 0 {name=p5 lab=tio[7:0]
}
C {devices/lab_wire.sym} 4820 -1540 0 1 {name=l54 sig_type=std_logic lab=tio[7:6]
}
C {devices/noconn.sym} 4760 -1540 0 0 {name=l55}
C {devices/lab_wire.sym} 2040 -870 0 1 {name=l5 sig_type=std_logic lab=gate}
C {devices/lab_wire.sym} 3090 -1300 0 0 {name=l22 sig_type=std_logic lab=gate}
C {devices/lab_wire.sym} 3130 -1300 0 1 {name=l26 sig_type=std_logic lab=vdd}
C {devices/ngspice_probe.sym} 1080 -900 0 0 {name=r17}
C {devices/vsource.sym} 400 -1170 0 1 {name=vmxm1
value=0
lvs_ignore=short
}
C {devices/vsource.sym} 1080 -1180 0 0 {name=vmxm2
value=0
lvs_ignore=short
}
C {devices/vsource.sym} 870 -530 0 1 {name=vmr3
value=0
lvs_ignore=short
}
C {devices/vsource.sym} 610 -530 0 1 {name=vmr2
value=0
lvs_ignore=short
}
C {devices/ngspice_get_expr.sym} 1010 -740 0 1 {name=r18 node="i=[to_eng [expr \{ [ ngspice::get_node i(i_r1) ]\} ] ]"
descr=""

}
C {devices/ngspice_get_expr.sym} 800 -740 0 1 {name=r19 node="i=[to_eng [expr \{ [ ngspice::get_node i(i_r3) ]\} ] ]"
descr=""

}
C {devices/ngspice_get_expr.sym} 670 -740 0 0 {name=r20 node="i=[to_eng [expr \{ [ ngspice::get_node i(i_r2) ]\} ] ]"
descr=""

}
C {devices/ngspice_get_expr.sym} 380 -740 0 1 {name=r21 node="i=[to_eng [expr \{ [ ngspice::get_node i(ie_xq1) ]\} ] ]"
descr=""

}
C {devices/ngspice_get_expr.sym} 450 -1200 0 0 {name=r22 node="i=[to_eng [expr \{ [ ngspice::get_node i(i_xm1) ]\} ] ]"
descr=""

}
C {devices/ngspice_get_expr.sym} 1030 -1210 0 1 {name=r23 node="i=[to_eng [expr \{ [ ngspice::get_node i(i_xm2) ]\} ] ]"
descr=""

}
C {devices/ngspice_get_expr.sym} 3150 -1450 0 0 {name=r24 node="i=[to_eng [expr \{ [ ngspice::get_node id_xbg_xmo1 ]\} ] ]"
descr=""
}
C {devices/lab_wire.sym} 2070 -1300 0 0 {name=l31 sig_type=std_logic lab=gate}
C {devices/lab_wire.sym} 2110 -1300 0 1 {name=l32 sig_type=std_logic lab=vdd
}
C {devices/ngspice_get_expr.sym} 2130 -1450 0 0 {name=r28 node="i=[to_eng [expr \{ [ ngspice::get_node id_xbg_xmb1 ]\} ] ]"
descr=""
}
C {devices/lab_wire.sym} 2110 -600 0 1 {name=l33 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 1910 -600 0 0 {name=l34 sig_type=std_logic lab=vss
}
C {devices/ngspice_probe.sym} 1970 -870 0 0 {name=r29}
C {devices/ngspice_get_expr.sym} 2100 -1270 2 0 {name=r38 node="vsat=[to_eng [expr \{ [ ngspice::get_node vsat_xbg_xmb1 ]\} ] ]"
descr=""
}
C {devices/ngspice_get_expr.sym} 1920 -630 0 0 {name=r39 node="vov=[to_eng [expr \{ [ ngspice::get_node vov_xbg_xmb3 ]\} ] ]"
descr=""
}
C {devices/ngspice_get_expr.sym} 1900 -630 0 1 {name=r40 node="vsat=[to_eng [expr \{ [ ngspice::get_node vsat_xbg_xmb3 ]\} ] ]"
descr=""
}
C {devices/ngspice_get_expr.sym} 2120 -630 0 0 {name=r41 node="vov=[to_eng [expr \{ [ ngspice::get_node vov_xbg_xmb2 ]\} ] ]"
descr=""
}
C {devices/ngspice_get_expr.sym} 2100 -630 0 1 {name=r42 node="vsat=[to_eng [expr \{ [ ngspice::get_node vsat_xbg_xmb2 ]\} ] ]"
descr=""
}
C {devices/ngspice_get_expr.sym} 1930 -80 0 0 {name=r43 node="i=[to_eng [expr \{ [ ngspice::get_node id_xbg_xmb3 ]\} ] ]"
descr=""
}
C {devices/ngspice_get_expr.sym} 2130 -80 0 0 {name=r44 node="i=[to_eng [expr \{ [ ngspice::get_node id_xbg_xmb2 ]\} ] ]"
descr=""
}
C {devices/ngspice_probe.sym} 1910 -700 0 1 {name=r45}
C {devices/ngspice_probe.sym} 2010 -700 0 0 {name=r46}
C {devices/lab_wire.sym} 2110 -700 0 0 {name=l41 sig_type=std_logic lab=vb1
}
C {devices/lab_wire.sym} 400 -1120 0 0 {name=l4 sig_type=std_logic lab=vx
}
C {devices/lab_wire.sym} 1080 -1120 0 0 {name=l9 sig_type=std_logic lab=vy
}
C {devices/lab_wire.sym} 4810 -1430 0 1 {name=l10 sig_type=std_logic lab=tio[0]
}
C {devices/vsource.sym} 4780 -1430 1 1 {name=vtio0
value=0
lvs_ignore=open
}
C {devices/lab_wire.sym} 4810 -1360 0 1 {name=l25 sig_type=std_logic lab=tio[1]
}
C {devices/vsource.sym} 4780 -1360 1 1 {name=vtio1
value=0
lvs_ignore=open
}
C {devices/lab_wire.sym} 4750 -1430 0 0 {name=l28 sig_type=std_logic lab=bias
}
C {devices/lab_wire.sym} 4750 -1290 0 0 {name=l30 sig_type=std_logic lab=eao
}
C {devices/lab_wire.sym} 4810 -1290 0 1 {name=l42 sig_type=std_logic lab=tio[2]
}
C {devices/vsource.sym} 4780 -1290 1 1 {name=vtio2
value=0
lvs_ignore=open
}
C {devices/lab_wire.sym} 4750 -1220 0 0 {name=l43 sig_type=std_logic lab=vx
}
C {devices/lab_wire.sym} 4810 -1220 0 1 {name=l44 sig_type=std_logic lab=tio[3]
}
C {devices/vsource.sym} 4780 -1220 1 1 {name=vtio3
value=0
lvs_ignore=open
}
C {devices/lab_wire.sym} 4750 -1150 0 0 {name=l45 sig_type=std_logic lab=vy
}
C {devices/lab_wire.sym} 4810 -1150 0 1 {name=l47 sig_type=std_logic lab=tio[4]
}
C {devices/vsource.sym} 4780 -1150 1 1 {name=vtio4
value=0
lvs_ignore=open
}
C {devices/lab_wire.sym} 4750 -1080 0 0 {name=l48 sig_type=std_logic lab=gate
}
C {devices/lab_wire.sym} 4810 -1080 0 1 {name=l49 sig_type=std_logic lab=tio[5]
}
C {devices/vsource.sym} 4780 -1080 1 1 {name=vtio5
value=0
lvs_ignore=open
}
C {devices/ipin.sym} 3610 -430 2 0 {name=p7 lab=trim[7:0]
}
C {devices/lab_wire.sym} 630 -710 0 1 {name=l50 sig_type=std_logic lab=vdd
}
C {devices/lab_wire.sym} 850 -710 0 0 {name=l52 sig_type=std_logic lab=vdd
}
C {devices/lab_wire.sym} 1060 -710 0 0 {name=l53 sig_type=std_logic lab=vdd
}
C {devices/lab_wire.sym} 3360 -1300 0 0 {name=l56 sig_type=std_logic lab=gate}
C {devices/lab_wire.sym} 3400 -1300 0 1 {name=l57 sig_type=std_logic lab=vdd}
C {devices/ngspice_get_expr.sym} 3420 -1450 0 0 {name=r15 node="i=[to_eng [expr \{ [ ngspice::get_node id_xbg_xmo2 ]\} ] ]"
descr=""
}
C {devices/opin.sym} 3610 -1170 0 0 {name=p4 lab=iout
}
C {devices/lab_wire.sym} 4090 -1170 0 1 {name=l6 sig_type=std_logic lab=en
}
C {devices/lab_wire.sym} 4050 -1170 0 0 {name=l58 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 4050 -1140 1 1 {name=l59 sig_type=std_logic lab=gate}
C {devices/lab_wire.sym} 4090 -510 0 1 {name=l62 sig_type=std_logic lab=enb
}
C {devices/lab_wire.sym} 4240 -790 0 0 {name=l63 sig_type=std_logic lab=enb
}
C {devices/lab_wire.sym} 4330 -800 0 1 {name=l64 sig_type=std_logic lab=en
}
C {devices/lab_wire.sym} 4240 -870 0 0 {name=l65 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 4240 -730 0 0 {name=l66 sig_type=std_logic lab=vss
}
C {devices/ipin.sym} 4450 -800 2 0 {name=p6 lab=en
}
C {devices/lab_wire.sym} 4050 -540 1 0 {name=l67 sig_type=std_logic lab=vb1
}
C {devices/lab_wire.sym} 4050 -510 0 0 {name=l60 sig_type=std_logic lab=vss
}
C {devices/ngspice_get_expr.sym} 4070 -1440 0 0 {name=r48 node="i=[to_eng [expr \{ [ ngspice::get_node id_xbg_xme1 ]\} ] ]"
descr=""
}
C {devices/ngspice_get_expr.sym} 4080 -80 0 0 {name=r50 node="i=[to_eng [expr \{ [ ngspice::get_node id_xbg_xme2 ]\} ] ]"
descr=""
}
C {devices/ngspice_get_expr.sym} 4260 -1440 0 0 {name=r51 node="i=[to_eng [expr \{ [ ngspice::get_node id_xbg_xme1 ]\} ] ]"
descr=""
}
C {devices/ngspice_get_expr.sym} 4260 -80 0 0 {name=r52 node="i=[to_eng [expr \{ [ ngspice::get_node id_xbg_xmi2 ]\} ] ]"
descr=""
}
C {devices/ngspice_probe.sym} 720 -1420 0 0 {name=r53}
C {devices/ngspice_probe.sym} 4420 -1420 0 0 {name=r54}
C {devices/ngspice_probe.sym} 4420 -180 0 0 {name=r55}
C {devices/ngspice_get_expr.sym} 2610 -80 0 0 {name=r57 node="i=[to_eng [expr \{ [ ngspice::get_node id_xbg_xms2 ]\} ] ]"
descr=""
}
C {devices/lab_wire.sym} 3890 -1170 0 1 {name=l15 sig_type=std_logic lab=en
}
C {devices/lab_wire.sym} 3850 -1170 0 0 {name=l16 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 3850 -1140 1 1 {name=l17 sig_type=std_logic lab=vs1
}
C {devices/lab_wire.sym} 2690 -770 0 1 {name=l18 sig_type=std_logic lab=vs1
}
C {devices/lab_wire.sym} 3850 -510 0 0 {name=l72 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 3890 -510 0 1 {name=l73 sig_type=std_logic lab=enb
}
C {devices/lab_wire.sym} 2390 -770 0 1 {name=l75 sig_type=std_logic lab=vs2
}
C {devices/lab_wire.sym} 3850 -540 3 1 {name=l80 sig_type=std_logic lab=vs2
}
C {devices/lab_wire.sym} 2590 -630 0 0 {name=l83 sig_type=std_logic lab=vs3
}
C {devices/lab_wire.sym} 2660 -810 0 1 {name=l81 sig_type=std_logic lab=en
}
C {devices/lab_wire.sym} 2550 -600 0 0 {name=l2 sig_type=std_logic lab=vx
}
C {devices/lab_wire.sym} 2590 -600 0 1 {name=l12 sig_type=std_logic lab=vss
}
C {devices/ngspice_probe.sym} 2590 -630 0 0 {name=r11}
C {devices/ngspice_probe.sym} 2430 -770 0 0 {name=r12}
C {devices/ngspice_probe.sym} 2750 -770 0 0 {name=r47}
C {devices/ngspice_get_expr.sym} 3870 -80 0 0 {name=r25 node="i=[to_eng [expr \{ [ ngspice::get_node id_xbg_xme4 ]\} ] ]"
descr=""
}
C {devices/ngspice_get_expr.sym} 3870 -1440 0 0 {name=r26 node="i=[to_eng [expr \{ [ ngspice::get_node id_xbg_xme3 ]\} ] ]"
descr=""
}
C {devices/lab_wire.sym} 2520 -810 0 1 {name=l14 sig_type=std_logic lab=en
}
C {devices/lab_wire.sym} 2520 -770 3 0 {name=l23 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 2660 -770 3 0 {name=l13 sig_type=std_logic lab=vss
}
C {devices/ngspice_probe.sym} 3430 -1170 0 0 {name=r32}
C {gf180_primitives/pfet_06v0.sym} 420 -1300 0 1 {name=M1
L=8u
W=8u
nf=1
m=6
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180_primitives/pfet_06v0.sym} 1060 -1300 0 0 {name=M2
L=8u
W=8u
nf=1
m=4
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180_primitives/pfet_06v0.sym} 2090 -1300 0 0 {name=MB1
L=8u
W=8u
nf=1
m=2
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180_primitives/pfet_06v0.sym} 3110 -1300 0 0 {name=MO1
L=8u
W=8u
nf=1
m=4
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180_primitives/pfet_06v0.sym} 3380 -1300 0 0 {name=MO2
L=8u
W=8u
nf=1
m=4
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180_primitives/pfet_06v0.sym} 3870 -1170 0 1 {name=ME3
L=1u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180_primitives/pfet_06v0.sym} 4070 -1170 0 1 {name=ME1
L=1u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180_primitives/pfet_06v0.sym} 4260 -870 0 1 {name=MI1
L=1u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {gf180_primitives/nfet_06v0.sym} 4260 -730 0 1 {name=MI2
L=1u
W=2u
nf=1 
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180_primitives/nfet_06v0.sym} 4070 -510 0 1 {name=ME2
L=1u
W=2u
nf=1 
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180_primitives/nfet_06v0.sym} 3870 -510 0 1 {name=ME4
L=1u
W=2u
nf=1 
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180_primitives/nfet_06v0.sym} 2570 -600 0 0 {name=MS2
L=1u
W=1u
nf=1 
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180_primitives/nfet_06v0.sym} 2660 -790 3 1 {name=MS4
L=1u
W=1u
nf=1 
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180_primitives/nfet_06v0.sym} 2520 -790 3 1 {name=MS3
L=1u
W=1u
nf=1 
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180_primitives/nfet_06v0.sym} 2370 -770 0 1 {name=MS1
L=1u
W=1u
nf=1 
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180_primitives/nfet_06v0.sym} 1930 -600 0 1 {name=MB3
L=8u
W=8u
nf=1 
m=2
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {gf180_primitives/nfet_06v0.sym} 2090 -600 0 0 {name=MB2
L=8u
W=8u
nf=1 
m=4
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {devices/ngspice_probe.sym} 1580 -750 0 1 {name=r16}
C {devices/lab_wire.sym} 3110 -640 0 0 {name=l27 sig_type=std_logic lab=vdd
}
C {gf180_primitives/pnp_05p00x05p00.sym} 420 -350 0 1 {name=Q1
model=pnp_05p00x05p00
spiceprefix=X
m=1}
C {gf180_primitives/pnp_05p00x05p00.sym} 1060 -350 0 0 {name=Q2
model=pnp_05p00x05p00
spiceprefix=X
m=8
}
C {devices/lab_wire.sym} 1700 -870 0 1 {name=l35 sig_type=std_logic lab=eao
}
C {devices/vsource.sym} 1880 -870 1 1 {name=vac 
value=0
spice_ignore="tcleval([if \{[file rootname [file tail [xschem get schname 0]]] == \\"ac_bandgap_stb\\"\} \{return \{open\}\} else \{return \{short\}\}])"
lvs_ignore=short
}
C {devices/lab_wire.sym} 4750 -1360 0 0 {name=l19 sig_type=std_logic lab=vs1
}
C {devices/vsource.sym} 1790 -870 1 1 {name=vnet
value=0
lvs_ignore=short
}
C {devices/ngspice_probe.sym} 3130 -550 0 0 {name=r35}
C {gf180_primitives/ppolyf_u_1k_6p0.sym} 610 -710 0 1 {name=R1
W=1e-6
L=340e-6
s=1
model=ppolyf_u_1k_6p0
spiceprefix=X
m=1
}
C {gf180_primitives/ppolyf_u_1k_6p0.sym} 870 -710 0 0 {name=R2
W=1e-6
L=340e-6
s=1
model=ppolyf_u_1k_6p0
spiceprefix=X
m=1
}
C {gf180_primitives/ppolyf_u_1k_6p0.sym} 1080 -710 0 0 {name=R3
W=1e-6
L=40e-6
s=1
model=ppolyf_u_1k_6p0
spiceprefix=X
m=1
}
C {gf180_primitives/ppolyf_u_1k_6p0.sym} 3130 -640 0 0 {name=RO
W=1e-6
L=220e-6
s=1
model=ppolyf_u_1k_6p0
spiceprefix=X
m=1
}
C {sch/bandgap_cm/bg_trimres/bg_trimres.sym} 3170 -370 0 1 {name=xtr
}
C {devices/lab_wire.sym} 3090 -430 0 0 {name=l36 sig_type=std_logic lab=vdd
}
C {devices/lab_wire.sym} 3090 -400 0 0 {name=l37 sig_type=std_logic lab=vss
}
C {gf180_primitives/pfet_06v0.sym} 4750 -750 0 0 {name=MDUM1
L=8u
W=8u
nf=1
m=28
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_06v0
spiceprefix=X
}
C {devices/lab_wire.sym} 4770 -780 0 0 {name=l38 sig_type=std_logic lab=vdd}
C {gf180_primitives/pnp_05p00x05p00.sym} 4750 -640 0 0 {name=QDUM
model=pnp_05p00x05p00
spiceprefix=X
m=16
}
C {devices/lab_wire.sym} 4730 -640 0 0 {name=l39 sig_type=std_logic lab=vss
}
C {gf180_primitives/nfet_06v0.sym} 4750 -530 0 0 {name=MBDUM2
L=8u
W=8u
nf=1 
m=14
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_06v0
spiceprefix=X
}
C {devices/lab_wire.sym} 4770 -560 0 0 {name=l40 sig_type=std_logic lab=vss
}
C {gf180_primitives/cap_mim_2f0_m4m5_noshield.sym} 2750 -700 0 0 {name=C1
W=10e-6
L=10e-6
model=cap_mim_2f0_m4m5_noshield
spiceprefix=X
m=1
}
C {gf180_primitives/ppolyf_u_1k_6p0.sym} 4770 -420 0 0 {name=RDUM
W=1e-6
L=20e-6
s=1
model=ppolyf_u_1k_6p0
spiceprefix=X
m=8
}
C {devices/lab_wire.sym} 4770 -450 0 0 {name=l46 sig_type=std_logic lab=vdd
}
